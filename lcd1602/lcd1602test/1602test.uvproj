# Keil uVision project 1602test.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC90C58RD+ STC
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF) IROM(0-0x7FFF) CLOCK(45000000) MODP2
  output: 1602test +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\..\lcd1602
  group Source Group 1
    ./: STARTUP.A51 main.c
    ../: lcd1602.c
